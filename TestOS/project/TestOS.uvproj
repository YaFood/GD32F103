# Keil uVision project TestOS.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: GD32F103VC GigaDevice
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TestOS
  c flags: Optim=1
  c include: ..\app;..\sdk;..\sdk\Peripherals\inc;..\sdk\CMSIS;..\os;..\driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group sdk
    ../sdk/CMSIS/: core_cm3.c system_gd32f10x.c
    ../sdk/Peripherals/src/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dma.c gd32f10x_eth.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_iwdg.c gd32f10x_mcudbg.c gd32f10x_misc.c gd32f10x_pwr.c gd32f10x_rcc.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdg.c
  group app
    ../app/: main.c test.c
  group startup
    ../startup/: startup_gd32f10x_hd.s
  group os
    ../os/: os_task.c
  group driver
    ../driver/: drv_led.c drv_uart.c
