# Keil uVision project TestLED.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: GD32F103VC GigaDevice
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TestLED
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c include: ..\app;..\driver;..\sdk;..\sdk\CMSIS;..\sdk\Peripherals;..\sdk\Peripherals\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup
    ../startup/: startup_gd32f10x_hd.s
  group app
    ../app/: main.c app_debug.c app_boot.c app_xmodem.c app_file.c app_upgrade.c
  group driver
    ../driver/: drv_led.c drv_key.c drv_systick.c drv_uart1.c drv_adc.c drv_i2c.c drv_at24c02c.c drv_gd25q40.c drv_spi.c drv_timer.c drv_backup.c drv_rtc.c drv_power.c drv_iwdg.c drv_fmc.c
  group sdk
    ../sdk/Peripherals/src/: gd32f10x_can.c gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dma.c gd32f10x_eth.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_iwdg.c gd32f10x_mcudbg.c gd32f10x_misc.c gd32f10x_pwr.c gd32f10x_rcc.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdg.c
    ../sdk/CMSIS/: core_cm3.c system_gd32f10x.c
